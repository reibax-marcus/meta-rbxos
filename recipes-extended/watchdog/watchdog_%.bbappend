# Enable watchdog service
SYSTEMD_AUTO_ENABLE = "enable"
