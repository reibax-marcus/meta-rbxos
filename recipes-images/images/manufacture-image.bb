require recipes-images/images/rbxos-image.bb

SUMMARY = "Manufacture image"
DESCRIPTION = "Contents all need packages to deploy a rootfs"

LICENSE = "CLOSED"

IMAGE_FSTYPES = "ext4"

