FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:prepend = "file://issue \
	               file://issue.net \
                  "
