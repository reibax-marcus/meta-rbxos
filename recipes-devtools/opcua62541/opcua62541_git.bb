PV = "1.2.4"
SRCREV = "v${PV}"

include opcua62541.inc
